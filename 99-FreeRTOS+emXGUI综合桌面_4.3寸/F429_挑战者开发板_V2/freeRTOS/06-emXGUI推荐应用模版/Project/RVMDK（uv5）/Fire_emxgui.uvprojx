# Keil uVision project Fire_emxgui.uvprojx, settings and files
target Fire_emxgui (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,X_GUI_USE_FREERTOS,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F4,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\bsp;..\..\User\FATFS;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\bsp\cm_backtrace;..\..\..\..\..\emXGUI_Lib\drv;..\..\..\..\..\emXGUI_Lib\arch\Inc;..\..\..\..\..\emXGUI_Lib\app\base;..\..\..\..\..\emXGUI_Lib\inc;..\..\User\app;..\..\User\app\Board_App;..\..\User\app\GUI_Demo;..\..\User\app\res;..\..\User\app\Board_App\mp3_player;..\..\User\OwnerDraw;..\..\User\app\Board_App\mp3_decoder;..\..\User\app\Board_App\mp3_decoder\pub;..\..\User\app\Board_App\mp3_decoder\real;..\..\User\app\Board_App\adc_Collect_voltage;..\..\..\..\..\..\..\module_code\libpng\源码\libpng\SRC;..\..\User\app\Board_App\T_RH;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\src\include\ipv4;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\src\include\lwip;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\src\include\netif;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\src\include;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\port\arch;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\port\FreeRTOS305;..\..\User\app\Board_App\NetworkDLG\lwip-1.4.1\port;..\..\User\app\Board_App\NetworkDLG\bsp;..\..\User\app\Board_App\NetworkDLG\lwipapp;..\..\User\app\Board_App\NetworkDLG;..\..\User\app\Board_App\gyro\mpu6050\driver\include;..\..\User\app\Board_App\gyro\mpu6050\driver\eMPL;..\..\User\app\Board_App\gyro\mpu6050\driver\stm32L;..\..\User\app\Board_App\gyro\mpu6050\eMPL-hal;..\..\User\app\Board_App\gyro\mpu6050\mllite;..\..\User\app\Board_App\gyro\mpu6050\mpl;..\..\User\app\Board_App\gyro;..\..\User\app\Board_App\gyro\mpu6050;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\User\app\Board_App\SimulateUDisk\USB_app;..\..\User\app\Board_App\SimulateUDisk;..\..\User\app\Board_App\Phone_SMS\sim900a;..\..\User\app\Board_App\recorder;..\..\..\..\..\emXGUI_Lib\app\base\boot_interface;..\..\User\app\Board_App\nes\InfoNes\InfoNES_v0.97J_RC1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\Fire_FreeRTOS.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h board.h cpuusage.c
  group BSP
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/wm8978/: bsp_wm8978.c
    ../../User/bsp/lcd/: bsp_lcd.c bsp_dma2d_emxgui.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../../User/bsp/flash/: bsp_spi_flash.c
    ../../User/bsp/sdio/: bsp_sdio_sd.c
    ../../User/bsp/dwt_delay/: core_delay.c
    ../../User/app/Board_App/gyro/mpu6050/: bsp_mpu_exti.c
    ../../User/app/Board_App/gyro/i2c/: i2c.c
    ../../User/bsp/beep/: bsp_beep.c
    ../../User/app/Board_App/Phone_SMS/sim900a/: bsp_sim900a.c bsp_usart_gsm.c
    ../../User/app/Board_App/clock/RTC/: bsp_rtc.c
    ../../User/bsp/board_test/: bsp_test.c
    ../../User/bsp/i2c/: bsp_i2c_ee.c bsp_i2c_gpio.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Fatfs
    ../../User/FATFS/: diskio.c ff.c ffconf.h
    ../../User/FATFS/option/: cc936.c extern_cc936.c syscall.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group emxgui/arch
    ../../../../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../../../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../../../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../../../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../../../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_picture_port.c gui_resource_port.c gui_startup.c gui_touch_port.c
    ../../../../../emXGUI_Lib/app/base/boot_interface/pic_load/: gui_pic_load.c
  group emxgui/inc
    ../../../../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h
  group emxgui/libs
    ../../../../../emXGUI_Lib/libs/: emXGUI100_MDK_M4.lib libjpeg_MDK_M4.lib libpng_MDK_M4.lib x_libc_MDK_M4.lib x_obj.cpp x_libc_MDK_M7.lib lodepng_app.c lodepng.c
  group OEM_Face
    ../../../../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group base_app
    ../../../../../emXGUI_Lib/app/base/: gui_desktop.c GUI_AppDef.h
    ../../../../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../../../../emXGUI_Lib/app/base/res_writer/: GUI_RES_Writer_Dialog.c backend_res_writer.c
  group app_res
    ../../../../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group MP3_decoder
    ../../User/app/Board_App/mp3_decoder/: mp3dec.c mp3tabs.c
    ../../User/app/Board_App/mp3_decoder/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/app/Board_App/mp3_decoder/real/arm/: asmmisc.s asmpoly_thumb2.s
  group gui_app
    ../../User/app/Board_App/: GUI_Board_App_Desktop.c
    ../../User/app/GUI_Demo/: CListMenu.cpp GUI_DEMO_SlideWindow.c GUI_App_Desktop.c GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_ShowWave.cpp GUI_DEMO_Scrollbar_OwnerDraw.c number_input.c GUI_DEMO_Number_Keyboard.c GUI_SelectDialogBox.c GUI_DEMO_Button_OwnerDraw.c GUI_DEMO_AutoMeter.c calculator.cpp GUI_DEMO_RadiaMenu.c GUI_DEMO_Checkbox.c GUI_DEMO_Listbox.c GUI_DEMO_Messagebox.c GUI_DEMO_Progressbar.c GUI_DEMO_Radiobox.c GUI_DEMO_Scrollbar.c GUI_DEMO_Textbox.c GUI_DEMO_Button.c GUI_DEMO_Settings.c GUI_DEMO_Button_Transparent.c
    ../../User/OwnerDraw/: Widget.c
  group board_app
    ../../User/app/Board_App/mp3_player/: GUI_MusicList_DIALOG.c GUI_MUSICPLAYER_DIALOG.c Backend_mp3Player.c
    ../../User/app/Board_App/mjpegplayer/: GUI_AVIList_DIALOG.c GUI_AVIPLAYER_DIALOG.c Backend_avifile.c Backend_vidoplayer.c
    ../../User/app/Board_App/pic_viewer/: GUI_PicViewr_Dialog.c
    ../../User/app/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
    ../../User/app/Board_App/camera/: GUI_Camera_Dialog.c bsp_ov5640.c ov5640_AF.c GUI_Camera_QRCode_Dialog.c
    ../../User/app/Board_App/adc_Collect_voltage/: GUI_ADC_CollectVoltage_Dialog.c bsp_adc.c
    ../../User/app/Board_App/T_RH/DHT11/: bsp_dht11.c
    ../../User/app/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/app/Board_App/NetworkDLG/: GUI_Network_Dialog.c
    ../../User/app/Board_App/NetworkDLG/bsp/LAN8742A/: LAN8742A.c stm32f429_eth.c
    ../../User/app/Board_App/NetworkDLG/lwipapp/: netconf.c tcp_echoclient.c tcp_echoserver.c udp_echoclient.c tcpecho.c
    ../../User/app/Board_App/gyro/: GUI_Gyro_Dialog.c
    ../../User/app/Board_App/SimulateUDisk/: GUI_SimulateUDisk_Dialog.c
    ../../User/app/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/app/Board_App/camera/QR_Decoder/: QR_Core_4_3.lib
    ../../User/app/Board_App/recorder/: GUI_RECORDER_DIALOG.c Backend_Recorder.c
    ../../User/app/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/app/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group LwIP
    ../../User/app/Board_App/NetworkDLG/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../User/app/Board_App/NetworkDLG/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../User/app/Board_App/NetworkDLG/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../User/app/Board_App/NetworkDLG/lwip-1.4.1/src/netif/: etharp.c
    ../../User/app/Board_App/NetworkDLG/lwip-1.4.1/port/FreeRTOS305/: ethernetif.c sys_arch.c
  group MPU_eMPL
    ../../User/app/Board_App/gyro/mpu6050/eMPL-hal/: eMPL_outputs.c
    ../../User/app/Board_App/gyro/mpu6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/app/Board_App/gyro/mpu6050/driver/stm32L/: log_stm32.c
  group MPU_mllite
    ../../User/app/Board_App/gyro/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../../User/app/Board_App/gyro/mpu6050/mpl/libmpllib_Keil_M4FP/: libmpllib.lib
  group USB Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB Device
    ../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB App
    ../../User/app/Board_App/SimulateUDisk/USB_app/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group DOC
    ../../: 必读说明.txt
