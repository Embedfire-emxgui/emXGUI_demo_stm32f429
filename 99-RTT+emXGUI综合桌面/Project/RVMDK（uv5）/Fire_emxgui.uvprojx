# Keil uVision project Fire_emxgui.uvprojx, settings and files
target Fire_emxgui (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emXGUI +hex
  c flags: Optim=2 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\User\bsp\led;..\..\User\bsp\lcd;..\..\User\bsp\sdram;..\..\User\bsp\touch;..\..\User\bsp\usart;..\..\User\bsp\flash;..\..\User\bsp\font;..\..\User\FATFS;..\..\rtthread\3.0.3\include;..\..\rtthread\3.0.3\include\libc;..\..\rtthread\3.0.3\components\cm_backtrace;..\..\User\bsp;..\..\emxgui\inc;..\..\emxgui\drv;..\..\emxgui\arch\Inc;..\..\User\app;..\..\User\app\GUI_Demo;..\..\User\app\Board_App;..\..\User\app\Board_App\mp3_decoder\real;..\..\User\app\Board_App\mp3_decoder\pub;..\..\User\app\res
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\emXGUI.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DOC
    ../../Doc/: readme.txt
  group USER
    ../../User/: main.c stm32f4xx_it.c board.c board.h rtconfig.h FatFs_test.c cpuusage.c
  group BSP
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/key/: bsp_key.c
    ../../User/bsp/lcd/: bsp_lcd.c dma2d_emxgui.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/touch/: bsp_touch_gt9xx.c bsp_i2c_touch.c
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/flash/: bsp_spi_flash.c
    ../../User/bsp/sdio/: bsp_sdio_sd.c
    ../../User/bsp/wm8978/: bsp_wm8978.c
    ../../User/bsp/dwt_delay/: core_delay.c
  group rtt/source
    ../../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/cm_backtrace
    ../../rtthread/3.0.3/components/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../rtthread/3.0.3/components/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group rtt/ports
    ../../rtthread/3.0.3/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Fatfs
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c syscall.c extern_cc936.c
  group MP3_decoder
    ../../User/app/Board_App/mp3_decoder/: mp3dec.c mp3tabs.c
    ../../User/app/Board_App/mp3_decoder/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/app/Board_App/mp3_decoder/real/arm/: asmmisc.s asmpoly_thumb2.s
  group emxgui/arch
    ../../emxgui/arch/: GUI_Arch.c GUI_GPU.c
    ../../emxgui/arch/OS_Options/: X_GUI_RTT.c
    ../../emxgui/arch/Inc/: gui_drv.h
  group emxgui/resource
    ../../emxgui/resource/xft_font/: ASCII_20_4BPP.c ASCII_24_4BPP.c ASCII_32_4BPP.c ASCII_40_4BPP.c LOGO_50_4BPP.c ICON_100_4BPP.c CONTROL_60_8BPP.c app_icon_200_200_4BPP.c
    ../../User/app/res/: ExitButton.c
  group emxgui/drv
    ../../emxgui/drv/: gui_drv_cfg.h gui_desktop.c gui_startup.c gui_lcd_port.c gui_mem_port.c gui_font_port.c gui_log_port.c gui_input_port.c gui_touch_port.c gui_resource_port.c gui_picture_port.c
  group emxgui/inc
    ../../emxgui/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h x_libc.h x_obj.h emXGUI_JPEG.h list.h Web_Color.h
  group emxgui/libs
    ../../emxgui/libs/: emXGUI100_MDK_M4.lib x_libc_MDK_M4.lib libjpeg_MDK_M4.lib x_obj.cpp
  group gui_app
    ../../User/app/: GUI_AppDef.h
    ../../User/app/GUI_Demo/: GUI_Base_Desktop.c GUI_App_Desktop.c GUI_DEMO_SlideWindow.c GUI_DEMO_ShowWave.cpp GUI_DEMO_Graphics_Accelerator.c CListMenu.cpp CListMenu.h
  group board_app
    ../../User/app/Board_App/: GUI_Board_App_Desktop.c
    ../../User/app/Board_App/rgb_led/: GUI_RGBLED_DIALOG.c Backend_RGBLED.c
    ../../User/app/Board_App/mp3_player/: GUI_MusicList_DIALOG.c GUI_MUSICPLAYER_DIALOG.c Backend_mp3Player.c
    ../../User/app/Board_App/mjpegplayer/: GUI_AVIList_DIALOG.c GUI_AVIPLAYER_DIALOG.c Backend_avifile.c Backend_vidoplayer.c
    ../../User/app/Board_App/camera/: GUI_Camera_Dialog.c bsp_ov5640.c ov5640_AF.c
    ../../User/app/Board_App/CDlg_MusicPlayer/: CDlg_MusicPlayer.c
  group tutorial_app
    ../../User/app/GUI_Demo/: GUI_DEMO_Hello.c
    ../../User/app/Tutorial_App/: GUI_Tutorial_App_Desktop.c
  group app_res
    ../../User/app/res/: blue_fish_bitmap.c crocodile_bitmap.c gui_demo_pic_jpeg.c red_fish_bitmap.c
